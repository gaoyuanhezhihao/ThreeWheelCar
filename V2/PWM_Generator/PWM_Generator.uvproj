# Keil uVision project PWM_Generator.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F120 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: PWM_Generator
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Init.c Init.h Timer.c Timer.h main.h
